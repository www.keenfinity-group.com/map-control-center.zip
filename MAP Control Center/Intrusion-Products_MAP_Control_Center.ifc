Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.0]
File name: Projektnummer
Time: 2023-06-22T08:54:17
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jun 22 08:54:17 2023 * Host: LIS-C-001FN * Database: C:\Users\ROG2OVR\AppData\Local\Temp\{9A21F82C-27A0-4F16-9D63-51200944C7F6}\ifc * Database version: 5507 * Database creation date: Thu Jun 22 08:54:15 2023 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Thu Jun 22 08:54:16 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jun 22 08:54:16 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 52, 30, 59, 765625; RefLongitude: 13, 23, 59, 998626; RefElevation: 0 m
Other - Category: Project Information; Client Name: Bauherr; Project Address: Projektadresse; Project Issue Date: Projekt Datum; Project Name: Projektname; Project Number: Projektnummer; Project Status: Projektstatus; Verfasser eMail: E-Mail; Verfasser Firma 1: Firma 1; Verfasser Firma 2: Firma 2; Verfasser PLZ Ort: PLZ Ort; Verfasser Strasse: Strasse; Verfasser Telefax: Telefax; Verfasser Telefon: Telefon

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Bauherr; Project Address: Projektadresse; Project Issue Date: Projekt Datum; Project Name: Projektname; Project Number: Projektnummer; Project Status: Projektstatus; Verfasser eMail: E-Mail; Verfasser Firma 1: Firma 1; Verfasser Firma 2: Firma 2; Verfasser PLZ Ort: PLZ Ort; Verfasser Strasse: Strasse; Verfasser Telefax: Telefax; Verfasser Telefon: Telefon

# IfcBuildingStorey, Ebene 0
LongName: Ebene 0; Elevation: 0 m
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Ebene
Graphics(Type) - Color: 16711680; Line Pattern: Verdeckt; Line Weight: 1; Symbol: Beschriftung Ebene: Beschriftung Ebene; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 m
Dimensions - Computation Height: 0 m
Identity Data - Building Story: yes; Name: Ebene 0; Structural: no
Other - Category: Levels; Family: Level: Ebene; Family and Type: Level: Ebene; Type: Level: Ebene; Type Id: Level: Ebene

# IfcDistributionControlElement: MAP Control Center, Intrusion-Products_MAP_Control_Center:MAP_Control_Center:392768
In: Ebene 0
Type - PredefinedType: USERDEFINED; Classification: Pr_75_30_30_03 Access control units (Uniclass 2015); Material: Glass, Plastic, White
Type - Constraints - Default Elevation: 1.3 m
Type - Dimensions - 2DSymbolOffset: 0.003 m; Dimension depth (cm): 3.9; Dimension height (cm): 15.6; Dimension width (cm): 17.1
Type - General - Current consumption (mA): 26 mA; Environmental class: II; IK Class: IK06; IP Class: IP31; Operating temperature (°C) (maximum): 55; Operating temperature (°C) (minimum): -10; Operating voltage (VDC) (maximum): 29; Operating voltage (VDC) (minimum): 16
Type - Identity Data - Description: MAP Control Center; Disclaimer: https://resources-boschsecurity-cdn.azureedge.net/public/information/bim/Disclaimer.pdf; InstallationManual: https://resources-boschsecurity-cdn.azureedge.net/public/documents/MAP_5000_Installation_Manual_enUS_45035997701400331.pdf; Manufacturer: Bosch Security and Safety Systems; OmniClass Number: 23.85.30.11; OmniClass Title: Access Controls; PlanningTools: NA; Product Information: https://resources-boschsecurity-cdn.azureedge.net/public/documents/MAP_Control_Center_(_Data_sheet_enUS_1427936139.pdf; Product Website: https://commerce.boschsecurity.com/nordics/en/MAP-5000-family/p/F.01U.245.557/; Type Name: MAP_Control_Center
Type - Materials and Finishes - Color: White Textured; Material: ABS plastic
Type - Other - Category: Security Devices; Family Name: Intrusion-Products_MAP_Control_Center
Pset_ManufacturerTypeInformation - Manufacturer: Bosch Security and Safety Systems
Constraints - Elevation: 0 m; Host: Level : Ebene 0; Level: Level: Ebene 0
Dimensions - Volume: 0.000945606 m3
Identity Data - CTN: IUI-MAP0001-2; Mark: 1; Material number: F.01U.245.557
Other - 2D_Flipped Position: yes; 2D_Original Position: no; Family: Intrusion-Products_MAP_Control_Center: MAP_Control_Center; Family and Type: Intrusion-Products_MAP_Control_Center: MAP_Control_Center; Schedule Level: Level: Ebene 0; Type: Intrusion-Products_MAP_Control_Center: MAP_Control_Center; Type Id: Intrusion-Products_MAP_Control_Center: MAP_Control_Center
Phasing - Phase Created: Phase 1
